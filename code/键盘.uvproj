# Keil uVision project 键盘.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 键盘
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../头文件1/: Keyboard.h STC15Fxxxx.H
