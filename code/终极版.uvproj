# Keil uVision project 终极版.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 终极版 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\头文件
  group Source Group 1
    ./: STARTUP.A51 zhongjiban.c
